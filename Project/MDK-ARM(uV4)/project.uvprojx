# Keil uVision project project.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\User\app\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Flash\Obj\output.sct
  group User
    ../../User/: main.c includes.h SysInfoTest.c FreeRTOSConfig.h
    ../../User/app/src/: paste.c
  group App
    ../../User/app/src/: bsp_PowerSwitch.c bsp_Collision.c bsp_Angle.c bsp_Action.c bsp_aw9523b.c bsp_DetectAct.c bsp_PulseMark.c bsp_IWDG.c bsp_Edgewise.c bsp_Remote.c bsp_communication.c bsp_Encoder.c bsp_motor.c bsp_Control.c bsp_Scope.c bsp_Position.c bsp_param.c bsp_stflash.c bsp_OffSiteSW.c bsp_CurrentFeedback.c bsp_CliffSW.c bsp_DustBox.c bsp_speaker.c bsp_RunControl.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_it.c stm32f10x_assert.c
    ../../User/bsp/src/: bsp_dwt.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_key.c bsp_led.c bsp_timer.c bsp_i2c_gpio.c bsp_user_lib.c bsp_ir_decode.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_exti.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt
